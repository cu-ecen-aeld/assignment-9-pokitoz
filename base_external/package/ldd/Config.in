## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
	bool "ldd-assignments"
	help
	  Compile .ko and application to be loaded
```
